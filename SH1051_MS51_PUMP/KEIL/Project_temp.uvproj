# Keil uVision project Project_temp.uvproj, settings and files
target Project_temp (MCS-51)
  device: MS51xA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Project_temp +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\driver;..\driver\driver_debug\inc;..\library\library_app\inc;..\library\library_debug\inc;..\driver\driver_app\inc;..\library\library_i2c\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
    ../library/library_app/src/: isr.c
  group Startup
    ../driver/Startup/: STARTUP.A51
  group driver
    ../driver/driver_app/src/: driver_app.c
    ../driver/driver_debug/src/: driver_debug.c
  group library
    ../library/library_app/src/: library_app.c
    ../library/library_debug/src/: library_debug.c
    ../library/library_i2c/src/: library_i2c.c
